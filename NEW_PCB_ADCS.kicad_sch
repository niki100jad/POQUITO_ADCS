File: NEW_PCB_ADCS.kicad_sch (KiCad schematic)
At the start: 9 parts, among them J1 SWD

Commit message: Update project to kicad 8
Parts:
- H1, H2, H3, H4: now left out of the parts list
